FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://disable_module.cfg"
